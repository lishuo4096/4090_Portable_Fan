# Keil uVision project 4090_V3.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8H1K08T Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: 4090_V3 +hex
  c flags: Optimize=7 SizeSpeed=1
  link misc: REMOVEUNUSED
  group headfiles
    ./: STARTUP.A51 main.h
    ../BT_Speaker/inc/: STC8H.H
    ../: TM1650.h
  group cfiles
    ./: Init.c ADC&Battery.c main.c Gosleep.c EERPOM.c WS2812.c UART1.c TouchKey.c Key.c
  group others
    ./: RCwakeuptest.c
  group ASM
    ./: ISR_JMP.a51
